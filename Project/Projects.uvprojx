# Keil uVision project Projects.uvprojx, settings and files
target App (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: N32WB033CE Nsingtech
  pack: Nsingtech.N32WB033_DFP.1.0.0
  cpu: IRAM(0x20000000,0x10000) IROM(0x01000000,0x80000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: App +hex
  AfterMake: MakeFile.exe
  c flags: Optim=1 oTime=1 OneElfS=1 uC99=1 v6Lang=3 wLevel=2
  c define: N32WB033, USE_STDPERIPH_DRIVER,USE_BLE_ROM_API
  c include: ..\Libraries\CMSIS\core;..\Libraries\CMSIS\device;..\Libraries\n32wb033_std_periph_driver\inc;..\Middlewares\ble_library\ns_ble_profile\dis\diss\api;..\Middlewares\ble_library\ns_ble_profile\bas\bass\api;..\Middlewares\ble_library\ns_ble_profile\hogp;..\Middlewares\ble_library\ns_ble_profile\hogp\hogpd\api;..\Middlewares\ble_library\ns_ble_profile\hogp\hogpd\src;..\Middlewares\ble_library\ns_ble_profile\hrp;..\Middlewares\ble_library\ns_ble_profile\hrp\hrps\api;..\Middlewares\ble_library\ns_ble_profile\hrp\hrps\src;..\Middlewares\ble_library\ns_ble_profile\rdts;..\Middlewares\ble_library\ns_ble_profile\rdts\rdtss\api;..\Middlewares\ble_library\ns_ble_profile\rdts\rdtsc\api;..\Middlewares\ble_library\ns_ble_stack\ip\ahi\api;..\Middlewares\ble_library\ns_ble_stack\ip\ble\hl\api;..\Middlewares\ble_library\ns_ble_stack\ip\ble\hl\inc;..\Middlewares\ble_library\ns_ble_stack\ip\ble\hl\src\gap;..\Middlewares\ble_library\ns_ble_stack\ip\ble\hl\src\gatt;..\Middlewares\ble_library\ns_ble_stack\ip\ble\hl\src\l2c;..\Middlewares\ble_library\ns_ble_stack\ip\ble\ll\api;..\Middlewares\ble_library\ns_ble_stack\ip\ble\ll\src;..\Middlewares\ble_library\ns_ble_stack\ip\ble\ll\src\llc;..\Middlewares\ble_library\ns_ble_stack\ip\ble\ll\src\lld;..\Middlewares\ble_library\ns_ble_stack\ip\ble\ll\src\llm;..\Middlewares\ble_library\ns_ble_stack\ip\em\api;..\Middlewares\ble_library\ns_ble_stack\ip\hci\api;..\Middlewares\ble_library\ns_ble_stack\ip\sch\api;..\Middlewares\ble_library\ns_ble_stack\modules\aes\api;..\Middlewares\ble_library\ns_ble_stack\modules\common\api;..\Middlewares\ble_library\ns_ble_stack\modules\dbg\api;..\Middlewares\ble_library\ns_ble_stack\modules\ecc_p256\api;..\Middlewares\ble_library\ns_ble_stack\modules\h4tl\api;..\Middlewares\ble_library\ns_ble_stack\modules\ke\api;..\Middlewares\ble_library\ns_ble_stack\modules\rwip\api;..\Middlewares\ble_library\ns_ble_stack\rfinit\api;..\Middlewares\ble_library\ns_ble_stack\arch;..\Middlewares\ble_library\ns_ble_stack\modules\common\api;..\Middlewares\ble_library\ns_ble_stack\modules\common\src;..\Middlewares\ble_library\ns_ble_stack\stack_common;..\Middlewares\ble_library\ns_ble_stack\arch;..\Middlewares\ble_library\ns_library\adv;..\Middlewares\ble_library\ns_library\timer;..\Middlewares\ble_library\ns_library\log;..\Middlewares\ble_library\ns_library\delay;..\Middlewares\ble_library\ns_library\sleep;..\Middlewares\ble_library\ns_library\sec;..\Middlewares\ble_library\ns_library\ble;.\inc\app_profile;.\inc;.\drive
  library: MicroLIB
  memory RVCT4: ROM 0x1002000 size 0x7f000
  memory RVCT9: RAM 0x20004000 size 0x10000
  link misc: ..\Middlewares\ble_library\ns_ble_stack\symdef\symbol_wb033.obj
  group Startup
    ../Libraries/CMSIS/device/startup/: startup_n32wb033.s
  group CMSIS
    ../Libraries/CMSIS/device/: system_n32wb033.c
  group Libraries
    ../Libraries/n32wb033_std_periph_driver/src/: misc.c n32wb033_exti.c n32wb033_gpio.c n32wb033_lpuart.c n32wb033_rcc.c n32wb033_dma.c n32wb033_usart.c n32wb033_tim.c
  group Middlewares/BleStack
    ../Middlewares/ble_library/ns_ble_stack/stack_common/: rwip_driver.c
    ../Middlewares/ble_library/ns_ble_stack/ip/ble/hl/src/att/: lib_att.c
  group Middlewares/BleProfile
    ../Middlewares/ble_library/ns_ble_profile/: prf.c prf_utils.c prf_utils_128.c
    ../Middlewares/ble_library/ns_ble_profile/rdts/: rdts_common.c
    ../Middlewares/ble_library/ns_ble_profile/rdts/rdtsc/src/: rdts_client.c rdts_client_task.c
    ../Middlewares/ble_library/ns_ble_profile/rdts/rdtss/src/: rdtss.c rdtss_task.c
  group Middlewares/BleLibraries
    ../Middlewares/ble_library/ns_library/sec/: ns_sec.c
    ../Middlewares/ble_library/ns_library/sleep/: ns_sleep.c
    ../Middlewares/ble_library/ns_library/timer/: ns_timer.c
    ../Middlewares/ble_library/ns_library/ble/: ns_ble.c ns_ble_task.c
  group Middlewares/BleApp
    ./src/app_profile/: app_rdtsc.c app_rdtss.c app_svc.c
    ./src/: core.c ble_port_rw.c ringbuffer.c stream.c
  group Driver
    ./src/: proto.c update.c uart.c one_wire.c flash.c lib.c
    ./drive/: Mytask.c yl1650.c
  group User
    ./src/: main.c my_ble.c led.c
